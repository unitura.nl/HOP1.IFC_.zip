Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: HOP1.IFC
Time: 2023-12-06T12:03:42
Written by: SwIFC
Made in: SolidWorks 2023

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: Backplate type 1
In: Default Storey
Material: Plywood WBP (Okoume)

# IfcBuildingElementProxy: HOP1-01
In: Default Storey
Material: Wood-Concrete
